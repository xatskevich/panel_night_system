# Keil uVision project panel_night_system.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: panel_night_system +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\files;.\inc;.\SPL_conf;.\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group files
    ./files/: ADC.h CAN.h GPIO.h main.h rcc.h timer.h ADC.c CAN.c GPIO.c main.c rcc.c timer.c
  group inc
    ./inc/: stm32f0xx.h stm32f0xx_adc.h stm32f0xx_can.h stm32f0xx_gpio.h stm32f0xx_iwdg.h stm32f0xx_misc.h stm32f0xx_rcc.h stm32f0xx_spi.h system_stm32f0xx.h
    ./SPL_conf/: stm32f0xx_conf.h
  group src
    ./src/: stm32f0xx_adc.c stm32f0xx_can.c stm32f0xx_gpio.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_spi.c
software components: CMSIS:CORE 5.0.2, Device:Startup 2.2.3
